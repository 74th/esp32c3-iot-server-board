# Repository 74th/esp32c3-iot-server-board

File README.md:

# IoT Server Board - ESP32C3

Board for converting Grove device to IoT Server using ESP32-C3-WROOM-02.

ESP32-C3-WROOM-02 を使った Grove デバイスを IoT Server 化するためのボード。

74thが作成するファームウェアについてはこちら https://github.com/74th/esp32c3-iot-server-firmware

## features

- ESP32-C3 onboard for WiFi connectivity
- Three Grove ports are equipped.
- Selectable 5V or 3.3V VCC for Grove port
- RGB LED for indicator
- Button for operation
- USB Type-C port for firmware rewriting

### 🇯🇵

- ESP32-C3 搭載で、WiFi 接続が可能
- Grove ポートを 3 ポート搭載
- Grove ポートの VCC は 5V、3.3V を選択可能
- インジケータ用の RGB LED 搭載
- 操作用のボタン搭載
- USB Type-C ポートで、ファームウェアの書き換え可能

## v1.2.0

- Semantics: [PDF](./esp32c3-pcb/esp32c3-iot-server-v1.2.0-semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32c3-iot-client-board%2Fblob%2Fv1.2.0%2Fpcb-kicad%2Fesp32c3-iot-client-board.kicad_sch)
- PCB [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fesp32c3-iot-client-board%2Fblob%2Fv1.2.0%2Fpcb-kicad%2Fesp32c3-iot-client-board.kicad_pcb)

### BOM

| Reference   | Name                                     | Quantity |
| ----------- | ---------------------------------------- | -------- |
| C1          | Capacitor 0805 1uF                       | 1        |
| C2, C4      | Capacitor 0805 100nF                     | 2        |
| C3, C5-C8   | Capacitor 0805 10uF                      | 5        |
| CH1         | HY2.0 Socket SMD 4Pin - I2C              | 1        |
| CH2         | HY2.0 Socket SMD 4Pin - UART             | 1        |
| CH3         | HY2.0 Socket SMD 4Pin - GPIO             | 1        |
| D1          | RGBLED 3528 SK6812MINI-E                 | 1        |
| J1          | Box Pin Header 2x3 Pitch 1.27mm          | 1        |
| J2          | USB Type-C Receptacle - USB2.0_C_v3      | 1        |
| R1, R2      | Capacitor 0805 1kΩ (NC)                  | 2        |
| R3, R4, R10 | Capacitor 0805 10kΩ                      | 3        |
| R5, R9      | Capacitor 0805 5.1kΩ                     | 2        |
| R6, R7      | Capacitor 0805 10Ω                       | 2        |
| R8          | Capacitor 0805 56kΩ                      | 1        |
| SW1         | Button SKRPABE010                        | 1        |
| SW2         | Button SKRPABE010                        | 1        |
| SW3         | Button SKRPABE010                        | 1        |
| U1          | WiFi MCU Module ESP32-C3-WROOM-02        | 1        |
| U2          | Regulator 3.3V SOT-223 AMS1117-3.3       | 1        |
| U3          | USB Power Protection IC SOT-23-6L CH217K | 1        |

## v1.1.1

### BOM

| Reference     | Name                                  | Quantity |
| ------------- | ------------------------------------- | -------- |
| C1            | Capacitor 0805 1uF                    | 1        |
| C2, C3        | Capacitor 0805 100nF                  | 2        |
| C4, C5        | Capacitor 0805 10uF                   | 2        |
| CH1           | HY2.0 Socket SMD 4Pin - I2C           | 1        |
| CH2           | HY2.0 Socket SMD 4Pin - UART          | 1        |
| CH3           | HY2.0 Socket SMD 4Pin - GPIO          | 1        |
| D1            | RGBLED 3528 SK6812MINI-E              | 1        |
| F1            | PolyFuse 1812 KT6-1100SMDI (NC)       | 1        |
| J1            | Box Pin Header 2x3 Pitch 1.27mm       | 1        |
| J2            | USB Type-C Receptacle - USB2.0_C_v3   | 1        |
| R1, R2, R5-R7 | Capacitor 0805 10kF                   | 5        |
| R3, R4        | Capacitor 0805 5.1kF                  | 2        |
| R8            | Capacitor 0805 42kF                   | 1        |
| SW1           | Button SKRPABE010                     | 1        |
| SW2           | Button SKRPABE010                     | 1        |
| SW3           | Button SKRPABE010                     | 1        |
| U1            | WiFi MCU Module ESP32-C3-WROOM-02     | 1        |
| U2            | Regulator 3.3V SOT-223 AMS1117-3.3    | 1        |
| U4            | USB Power Protection IC SOT-26 CH214K | 1        |

## KiCad design modules-pcb/ir_send/ir_send.kicad_pcb

Parts:
CH1: Grove; Connector_HY-2.0_SMD_4Pin
D1, D2: LED; PinOut_Pin_2_1GND
Q1: 2N7002; Package_SOT-23
R1, R3: 27R; Register_0805_2012
R2: 10kR; Register_0805_2012

Connections:
+5V: CH1.3 (VCC), R1.1, R3.1
GND: CH1.4 (GND), Q1.2 (S)
unnamed: CH1.2 (SDA), R2.1
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), D2.1 (K), Q1.3 (D)
unnamed: D2.2 (A), R3.2
unnamed: Q1.1 (G), R2.2

Board: 2 copper layers, 14.0 x 16.5 mm, 10 parts (5 on the bottom side), 7 nets.

Other parts of the board:
M2, M2#2: Hole_M2_2.0
MISC-ICON: LOGO; Logo_74th_4mm

## KiCad design esp32s3-pcb/esp32s3-iot-client-board.kicad_pcb

Parts:
C1: 1u; Capacitor_0805_2012
C2, C4: 100n; Capacitor_0805_2012
C3, C6, C8: 10u; Capacitor_0805_2012
C5, C7: 22u; Capacitor_0805_2012
CH1: I2C; Connector_HY-2.0_SMD_4Pin
CH2: UART; Connector_HY-2.0_SMD_4Pin
CH3: GPIO; Connector_HY-2.0_SMD_4Pin
D1: SK6812MINI; LED_SK6812MINI-E_BACK-RIGHT
J1: Prog; Connector_BoxPinHeader_2x03_P1.27mm
J2: USB2.0_C_v3; Connector_USB-C-Receptacle_SMT_12-Pin_MidMount_Simple
JP1, JP2, JP3: Jumper_3_Open; SolderJumper-3
R1, R2: 1k(NC); Register_0805_2012
R3, R10: 10k; Register_0805_2012
R5, R9: 5.1k; Register_0805_2012
R6, R7: 10; Register_0805_2012
R8: 56k; Register_0805_2012
SW1: G3; Switch_SKRPABE010
SW2: BOOT; Switch_SKRPABE010
SW3: RST; Switch_SKRPABE010
U1: ESP32-S3-WROOM-1
U2: AMS1117-3.3; Package_SOT-223-3
U3: CH217K; Package_SOT-23-6

Connections:
+3V3: C1.1, C2.1, C5.1, D1.1 (VDD), JP1.3 (B), JP2.3 (B), JP3.3 (B), R3.1, U1.2 (3V3), U2.2 (VO)
+5V: C7.1, J1.2 (VCC), JP1.1 (A), JP2.1 (A), JP3.1 (A), U2.3 (VI), U3.1 (VOUT)
/BOOT: J1.6 (IO0), SW2.2, U1.27 (GPIO0/BOOT)
/EN: C4.1, J1.1 (EN), R3.2, SW3.2, U1.3 (EN)
/LED: D1.4 (DIN), U1.7 (GPIO7/TOUCH7/ADC1_CH6)
/P.GPIO-D0: CH3.1 (SCL), U1.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1)
/P.GPIO-D1: CH3.2 (SDA), U1.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD)
/P.I2C-SCL: CH1.1 (SCL), R2.2, U1.39 (GPIO1/TOUCH1/ADC1_CH0)
/P.I2C-SDA: CH1.2 (SDA), R1.2, U1.38 (GPIO2/TOUCH2/ADC1_CH1)
/P.UART.RX: CH2.1 (Host_RX), U1.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
/P.UART.TX: CH2.2 (Host_TX), U1.10 (GPIO17/U1TXD/ADC2_CH6)
/Prog-RX: J1.5 (RXD0), U1.36 (U0RXD/GPIO44/CLK_OUT2)
/Prog-TX: J1.3 (TXD0), U1.37 (U0TXD/GPIO43/CLK_OUT1)
/SW: SW1.2, U1.5 (GPIO5/TOUCH5/ADC1_CH4)
/USBD+: J2.3 (D+), R7.1
/USBD-: J2.2 (D-), R6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, CH1.4 (GND), CH2.4 (GND), CH3.4 (GND), D1.3 (GND), J1.4 (GND), J2.4 (GND), R5.2, R8.2, R9.2, R10.2, SW1.1, SW2.1, SW3.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.1 (GND), U3.2 (GND)
unnamed: C3.1, CH1.3 (VCC), JP1.2 (C), R1.1, R2.1
unnamed: C6.1, CH2.3 (VCC), JP2.2 (C)
unnamed: C8.1, CH3.3 (VCC), JP3.2 (C)
unnamed: J2.5 (CC1), R5.1
unnamed: J2.6 (CC2), R9.1
unnamed: J2.1 (VBUS), U3.6 (VIN)
unnamed: R7.2, U1.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-)
unnamed: R6.2, U1.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+)
unnamed: R10.1, U3.4 (EN#)
unnamed: R8.1, U3.5 (ISET)

Notes on the sheet:
ESP32 Module
Builtin Device
M5StackCoreS3のPort.Aに基づく
M5GOBottomのPort.Bに基づく
M5GOBottomのPort.Cに基づく
Programing Port
Grove Device Port
Power & USB

Board: 2 copper layers, 38.1 x 49.5 mm, 36 parts (20 on the bottom side), 27 nets.

Other parts of the board:
M1, M2, M3, M4: M2-Hole

## KiCad design esp32c3-iot-client-board.kicad_pcb

Parts:
C1: 1u; Capacitor_0805_2012
C2, C3: 100n; Capacitor_0805_2012
C4, C5: 10u; Capacitor_0805_2012
CH1: I2C; HY2.0_Socket_SMD_4Pin
CH2: UART; HY2.0_Socket_SMD_4Pin
CH3: GPIO; HY2.0_Socket_SMD_4Pin
D1: SK6812MINI; YS-SK6812MINI-E-BACK-RIGHT
F1: Polyfuse; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1: Prog; BoxPinHeader_2x03_P1.27mm_Vertical
J2: USB2.0_C_v3; USB-C-12-Pin-MidMount-ali-v5
JP1, JP2, JP3: Jumper_3_Open; VCC_Selector_Jumper
R1, R2, R5, R6, R7: 10k; Capacitor_0805_2012
R3, R4: 5.1k; Capacitor_0805_2012
R8: 42k; Capacitor_0805_2012
SW1: G3; SKRPABE010
SW2: BOOT; SKRPABE010
SW3: RST; SKRPABE010
U1: ESP32-C3-WROOM-02
U2: AMS1117-3.3; SOT-223-3_TabPin2
U4: CH217K; SOT-23-6

Connections:
+3V3: C1.1, C2.1, C4.1, JP1.3 (B), JP2.3 (B), JP3.3 (B), R1.1, R2.1, U1.1 (3V3), U2.2 (VO)
+5V: C5.1, D1.1 (VDD), F1.1, J1.2 (VCC), JP1.1 (A), JP2.1 (A), JP3.1 (A), U2.3 (VI), U4.1 (VOUT)
/BOOT: J1.6 (IO0), SW2.2, U1.8 (GPIO9)
/EN: C3.1, J1.1 (EN), R1.2, SW3.2, U1.2 (EN/CHIP_PU)
/G0: CH1.1 (SCL), R6.2, U1.18 (GPIO0/ADC1_CH0/XTAL_32K_P)
/G1: CH1.2 (SDA), R5.2, U1.17 (GPIO1/ADC1_CH1/XTAL_32K_N)
/G3: SW1.2, U1.15 (GPIO3/ADC1_CH3)
/G4: CH3.1 (D0), U1.3 (GPIO4/ADC1_CH4)
/G5: CH3.2 (D1), U1.4 (GPIO5/ADC2_CH0)
/LED: D1.4 (DIN), U1.16 (GPIO2/ADC1_CH2)
/RX: CH2.1 (RX), J1.5 (RXD0), U1.11 (GPIO20/U0RXD)
/TX: CH2.2 (TX), J1.3 (TXD0), U1.12 (GPIO21/U0TXD)
/USBD+: J2.3 (D+), U1.14 (GPIO19/USB_D+)
/USBD-: J2.2 (D-), U1.13 (GPIO18/USB_D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, CH1.4 (GND), CH2.4 (GND), CH3.4 (GND), D1.3 (GND), J1.4 (GND), J2.4 (GND), R3.2, R4.2, R7.2, R8.2, SW1.1, SW2.1, SW3.1, U1.9 (GND), U1.19 (GND), U2.1 (GND), U4.2 (GND)
unnamed: CH1.3 (VCC), JP1.2 (C), R5.1, R6.1
unnamed: CH2.3 (VCC), JP2.2 (C)
unnamed: CH3.3 (VCC), JP3.2 (C)
unnamed: J2.5 (CC1), R3.1
unnamed: J2.6 (CC2), R4.1
unnamed: F1.2, J2.1 (VBUS), U4.6 (VIN)
unnamed: R2.2, U1.7 (GPIO8)
unnamed: R7.1, U4.4 (EN#)
unnamed: R8.1, U4.5 (ISET)

Notes on the sheet:
ESP32 Module
Builtin Device
Programing Port
Grove Device Port
Power & USB

Board: 2 copper layers, 38.1 x 49.5 mm, 33 parts (17 on the bottom side), 24 nets.

Other parts of the board:
M1, M2, M3, M4: M2-Hole

## Commit log

2023-07-29 v1.0.0
2023-08-28 update case
2023-08-28 organize folder
2023-08-28 add LICENSE
2023-09-01 update document
2023-09-02 v1.1.1
2023-09-13 v1.2.0
2024-06-09 dumping register
2024-06-30 rename
2024-06-30 ir send module
2024-07-07 add photo
2024-09-28 esp32-s3
